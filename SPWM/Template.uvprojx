# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\beep;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\oled;.\APP\adc;.\APP\uart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_usart.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f4xx.c
  group Public
    ./Public/: system.c SysTick.c
  group APP
    ./APP/pwm/: pwm.c
    ./APP/time/: time.c
    ./APP/oled/: oled.c
    ./APP/adc/: adc.c
    ./APP/led/: led.c
